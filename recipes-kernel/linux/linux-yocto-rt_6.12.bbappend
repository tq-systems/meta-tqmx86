require linux-yocto-tqmx86-6.12.inc

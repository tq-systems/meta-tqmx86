require linux-yocto-tqmx86-6.18.inc

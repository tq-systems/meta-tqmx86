FILESEXTRAPATHS_prepend_tqmx86 := "${THISDIR}/files:"

SRC_URI_append_tqmx86 = " \
	file://nct7802.cfg \
"
